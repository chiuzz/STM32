# Keil uVision project LED.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F030F4 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.2.0
  cpu: IROM(0x08000000,0x4000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F0XX_LD,
  c include: ..\ST_Lib\inc;..\ST_Lib\src;..\System\CMSIS;..\System\startup;..\User;..\My_Lib\delay;..\My_Lib\LED;C:\Keil_v5\ARM\Pack\ARM\CMSIS\4.2.0\CMSIS\Include;..\ucosii\core;..\ucosii\port
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group User
    ../User/: main.c
  group ST_Lib
    ../ST_Lib/src/: stm32f0xx_gpio.c stm32f0xx_rcc.c
  group My_Lib
    ../My_Lib/LED/: led.c
    ../My_Lib/delay/: delay.c
  group System
    ../System/CMSIS/: core_cm0.h core_cm0plus.h stm32f0xx.h stm32f0xx_conf.h system_stm32f0xx.c system_stm32f0xx.h
    ../System/startup/: startup_stm32f0xx.s
  group ucosii_core
    ../ucosii/core/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group ucosii_port
    ../ucosii/port/: os_cfg.h os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
