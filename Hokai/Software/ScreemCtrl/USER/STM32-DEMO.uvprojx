# Keil uVision project STM32-DEMO.uvprojx, settings and files
target LED-DEMO (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32-DEMO +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\CMSIS;..\FWlib\inc;..\USER;..\BSP;..\uCOS-II;..\uCOS-II\Ports;..\uCOS-II\Source;..\APP;..\xLib\inc;..\APP\inc;..\..\Ctrl\SYSTEM\delay
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group startup
    ../CMSIS/startup/: startup_stm32f10x_hd.s
  group USER
    ./: main.c stm32f10x_it.c
  group FWlib
    ../FWlib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_usart.c misc.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group BSP
    ../BSP/: BSP.c led.c usart1.c usart3.c
  group APP
    ../APP/: app.c
    ../APP/src/: ModuleServer.c ModuleUart.c ModuleKey.c ModuleScr.c
  group uCOS-II\Source
    ../uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uCOS-II\Ports
    ../uCOS-II/Ports/: os_cpu_a.asm os_cpu_c.c os_dbg.c
  group xLib
    ../xLib/src/: dllist.c MsgQueue.c
software components: CMSIS:CORE 5.1.1
