# Keil uVision project Template.uvprojx, settings and files
target Template (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\FWLIB\inc;..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\FreeRTOS\config;..\FreeRTOS\include;..\FreeRTOS\port\RVDS\ARM_CM4F
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx.h stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h system_stm32f4xx.c system_stm32f4xx.h includes.h
  group CORE
    ../CORE/: core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h startup_stm32f40_41xxx.s
  group HARDWARE
    ../HARDWARE/led/: led.c
    ../HARDWARE/beep/: beep.c
    ../HARDWARE/key/: key.c
    ../HARDWARE/lcd/: lcd.c
    ../HARDWARE/flash/: flash.c
  group Application
    ../Application/: ModuleNetWork.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_fsmc.c stm32f4xx_flash.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart2.c usart3.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group FreeRTOS/src
    ../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS/port
    ../FreeRTOS/port/MemMang/: heap_4.c
    ../FreeRTOS/port/RVDS/ARM_CM4F/: port.c
  group FreeRTOS/config
    ../FreeRTOS/config/: FreeRTOSConfig.h
  group ESP8266
    ../ESP8266/: common.c
